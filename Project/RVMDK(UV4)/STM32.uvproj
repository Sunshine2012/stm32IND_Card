# Keil uVision project STM32.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,uart1
  c include: ..\..\BSP\inc;..\..\USER\inc;..\..\Libraries\FWlib\inc;..\..\BSP
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group src
    ../../USER/src/: frame.c main.c menu.c stm32f10x_it.c
  group bsp
    ../../BSP/src/: bsp_can.c bsp_dac.c bsp_delay.c bsp_exti.c bsp_general_time.c bsp_i2c2.c bsp_iwdg.c bsp_led.c bsp_matrix_key.c bsp_stm_flash.c bsp_usart1.c Queue.c bsp_spi_flash.c bsp_lcd12864.c bsp_font_flash.c
  group lib
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
